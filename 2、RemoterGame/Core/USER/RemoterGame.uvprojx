# Keil uVision project RemoterGame.uvprojx, settings and files
target Firmware_F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Firmware_F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\COMMON\interface;..\COMMUNICATE\interface;..\CONFIG\interface;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\GUI_APP\interface;..\GUI_DRV\interface;..\HARDWARE\interface;..\RTT;..\USB\STM32_USB-FS-Device_Driver\inc;..\USB\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8002400 size 0x1dc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group COMMUNICATE
    ../COMMUNICATE/src/: APP_JoyStick.c BSP_List.c APP_Game.c
  group GUI_APP
    ../GUI_APP/src/: APP_Display.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c
  group HARDWARE
    ../HARDWARE/src/: key.c led.c oled.c adc.c bsp_key.c
  group GUI_DRV
    ../GUI_DRV/src/: gui_basic.c gui_menu.c lcmdrv.c button.c messagebox.c scrollbar.c text.c windows.c font.c
  group FreeRTOS
    ../FreeRTOS/: timers.c croutine.c event_groups.c list.c queue.c tasks.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s
  group README
    ../: README.TXT
